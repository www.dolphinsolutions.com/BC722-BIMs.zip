Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2019-04-12T08:41:18
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 12 08:41:18 2019 * Host: BIM-HP * Database: C:\Users\dcole\AppData\Local\Temp\{D3C879B6-82A2-45FC-BE2F-B16ACCBF7A31}\ifc * Database version: 5507 * Database creation date: Fri Apr 12 08:41:17 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 12 08:41:17 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 12 08:41:18 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: P:\Fastrack\53721_DOLPHIN SOLUTIONS LIMITED\ADDITIONAL DRAWINGS 2019 BIM\04$APRIL\BC722.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Line Pattern: -3000010; Line Weight: 1; Color: 0; Symbol at End 2 Default: yes; Symbol at End 1 Default: no

# IfcBuildingElementProxy: BC722 Dolphin Spare Toilet Roll Holder, BC722:BC722 Dolphin Spare Toilet Roll Holder:15251
In: Level 1
Constraints - Level: Level: Level 1; Host: Level : Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Volume: 0.000114993 m3; Capacity Toilet Roll: 2 spare toilet rolls; Width: 90mm; Projection: 97.5mm; Height: 287mm
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Dolphin Solutions Ltd.
Pset_BuildingElementProxyCommon - Reference: BC722 Dolphin Spare Toilet Roll Holder
Identity Data - Assembly Description: Other Plumbing Fixtures; URL: www.dolphinsolutions.co.uk; Model: BC722; Tel No.: +44 (0) 1424 202 224; Email: info@dolphinsolutions.co.uk; Assembly Code: D2010900; Manufacturer: Dolphin Solutions Ltd.; Description: Spare toilet roll holder; Address: Southpoint, Compass Park, Junction Road, Bodiam, TN32 5BS; Fax No.: +44 (0) 1424 205 200
General - Product Data: Timeless design for prestigious appearance in high class enviroments. 304 stainless steel for easy care and durability. Robust 'hidden fix' anti-rotation wall plate fixing for secure anti-theft mounting. Avialable in satin (brushed) stainless steel to compliment other Dolphin products. Designed to hold 2 spare toilet rolls.; Product Page Link: https://www.dolphinsolutions.co.uk/product/spare-toilet-roll-holder
